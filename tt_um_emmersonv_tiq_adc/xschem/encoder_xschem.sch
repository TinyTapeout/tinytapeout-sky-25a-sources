v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N -120 -70 -100 -70 {lab=clk}
N -120 -50 -100 -50 {lab=t0}
N -120 -30 -100 -30 {lab=t1}
N -120 -10 -100 -10 {lab=t2}
N -120 10 -100 10 {lab=t3}
N -120 30 -100 30 {lab=t4}
N -120 50 -100 50 {lab=t5}
N -120 70 -100 70 {lab=t6}
N 100 -20 120 -20 {lab=o2}
N 100 -0 120 -0 {lab=o1}
N 100 20 120 20 {lab=o0}
C {encoder.sym} 50 50 0 0 {name=A1 model=encoder}
C {ipin.sym} -120 -70 0 0 {name=p1 lab=clk}
C {ipin.sym} -120 -50 0 0 {name=p2 lab=t0}
C {ipin.sym} -120 -30 0 0 {name=p3 lab=t1}
C {ipin.sym} -120 -10 0 0 {name=p4 lab=t2}
C {ipin.sym} -120 10 0 0 {name=p5 lab=t3}
C {ipin.sym} -120 30 0 0 {name=p6 lab=t4}
C {ipin.sym} -120 50 0 0 {name=p7 lab=t5}
C {ipin.sym} -120 70 0 0 {name=p8 lab=t6}
C {opin.sym} 120 -20 0 0 {name=p9 lab=o2}
C {opin.sym} 120 0 0 0 {name=p10 lab=o1}
C {opin.sym} 120 20 0 0 {name=p11 lab=o0}

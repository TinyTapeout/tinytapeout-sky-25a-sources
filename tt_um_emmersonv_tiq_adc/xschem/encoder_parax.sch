v {xschem version=3.4.7 file_version=1.2}
G {}
K {}
V {}
S {*test}
E {}
N -100 -80 -70 -80 {lab=clk}
N -100 -60 -70 -60 {lab=t0}
N -100 -40 -70 -40 {lab=t1}
N -100 -20 -70 -20 {lab=t2}
N -100 -0 -70 0 {lab=t3}
N -100 20 -70 20 {lab=t4}
N -100 40 -70 40 {lab=t5}
N -100 60 -70 60 {lab=t6}
N 80 90 80 120 {lab=VGND}
N 80 -140 80 -110 {lab=VPWR}
N 230 -30 250 -30 {lab=o0}
N 230 -10 250 -10 {lab=o1}
N 230 10 250 10 {lab=o2}
C {encoderr.sym} 80 -10 0 0 {name=x1}
C {iopin.sym} 80 -140 0 0 {name=p1 lab=VPWR}
C {iopin.sym} 80 120 0 0 {name=p2 lab=VGND}
C {ipin.sym} -100 -80 0 0 {name=p3 lab=clk}
C {ipin.sym} -100 -60 0 0 {name=p4 lab=t0}
C {ipin.sym} -100 -40 0 0 {name=p5 lab=t1}
C {ipin.sym} -100 -20 0 0 {name=p6 lab=t2}
C {ipin.sym} -100 0 0 0 {name=p7 lab=t3}
C {ipin.sym} -100 20 0 0 {name=p8 lab=t4}
C {ipin.sym} -100 40 0 0 {name=p9 lab=t5}
C {ipin.sym} -100 60 0 0 {name=p10 lab=t6}
C {opin.sym} 250 -30 0 0 {name=p11 lab=o0}
C {opin.sym} 250 -10 0 0 {name=p12 lab=o1}
C {opin.sym} 250 10 0 0 {name=p13 lab=o2}
